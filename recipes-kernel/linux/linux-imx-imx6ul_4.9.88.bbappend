#FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

#SRC_URI_append     = " file://imx6ulval6_changes.diff"
